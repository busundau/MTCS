# Keil uVision project emWin_SimpleDemo.uvproj, settings and files
target emWin_SimpleDemo_ILI9341 (6190000::V6.19::ARMCLANG)
  device: M032KIAAE Nuvoton
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: 20260115-MTCS_LCD_M032_e459 +hex
  AfterMake: fromelf --bin ".\Output\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: .\hello.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DEMO_320x240__
  c include: .\Library\CMSIS_5.9.0;.\Library\Device\M031\Include;.\Library\StdDriver\inc;.\Library\emWin\Config;.\Library\emWin\Include;.\Library\emWin\lcm;.\Library\emWin\tslib;.\Include;.\Library\StdDriver\src
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/M031/Source/: system_M031Series.c
    ./Library/Device/M031/Source/ARM/: startup_M031Series.s
  group Library
    ./Source/: DialogFunction.c
    ./Library/StdDriver/src/: clk.c gpio.c sys.c timer.c fmc.c uart.c adc.c usci_spi.c pdma.c retarget.c i2c.c pwm.c
  group User
    ./Source/: main.c PTT_ISR.c
  group emWin
    ./Library/emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h
    ./Library/emWin/Lib/: NUemWin_CM0_Keil.lib
  group Application
    ./Application/: jpg.c Pg_Language_Big5.c Pg_Language_En.c Pg_Language_Gb.c Pg_Tool_Mode_Big5.c Pg_Tool_Mode_En.c Pg_Tool_Mode_Gb.c Pg_Call_Job_Big5.c Pg_Call_Job_En.c Pg_Call_Job_Gb.c Pg_JS_0_Job_Big5.c Pg_JS_0_Job_En.c Pg_JS_0_Job_Gb.c Pg_JS_1_JobSEQ_Big5.c Pg_JS_1_JobSEQ_En.c Pg_JS_1_JobSEQ_Gb.c Pg_JS_2_Step2_1_Big5.c Pg_JS_2_Step2_1_En.c Pg_JS_2_Step2_1_Gb.c Pg_JS_3_Step2_2_Big5.c Pg_JS_3_Step2_2_En.c Pg_JS_3_Step2_2_Gb.c Pg_Net_Info_Big5.c Pg_Net_Info_En.c Pg_Net_Info_Gb.c Pg_Net_AP_Info_Big5.c Pg_Net_AP_Info_En.c Pg_Net_AP_Info_Gb.c Pg_Tool_Info_Big5.c Pg_Tool_Info_En.c Pg_Tool_Info_Gb.c Pg_Home_Big5.c Pg_Home_En.c Pg_Home_Gb.c
  group Font
    ./Source/: Font_Boot_Menu_Microsoft JhengHei_22B.c Font_Pg_JS_1_JobSEQ_Microsoft JhengHei_22B.c Font_Pg_JS_0_Job_Microsoft JhengHei_22B.c FontName.c Font_ALLPage_Button_Microsoft JhengHei_16B.c Font_ALLPage_WinTitle_DFKai-SB_16B.c Font_Pg_Home_Microsoft JhengHei_19B.c Font_Pg_Home_Microsoft JhengHei_20B.c Font_Pg_Home_Microsoft JhengHei_192B.c Font_Pg_Language_Microsoft JhengHei_22B.c Font_Pg_Tool_Mode_Microsoft JhengHei_22B.c Font_Pg_Tool_Mode_Microsoft JhengHei_26B.c Font_Pg_JS_2_Step2_1_Microsoft JhengHei_22B.c Font_Pg_JS_2_Step2_1_Microsoft JhengHei_16B.c Font_Pg_JS_2_Step2_2_Microsoft JhengHei_22B.c Font_Pg_Tool_Info_Microsoft JhengHei_22B.c Font_Pg_Net_Info_Microsoft JhengHei_19B.c Font_Pg_Net_AP_Info_Microsoft JhengHei_22B.c
    ./Library/emWin/lcm/: ILI9341.c
    ./: 燒錄注意事項.txt
target emWin_SimpleDemo_ST7735 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: M032SG8AE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: emWin_SimpleDemo_ST7735
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEMO_160x128__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\..\..\..\Library\NuMaker\emWin\tslib;..\..\..\..\Library\NuMaker\emWin\lcm
  asm define: Stack_Size=0x800
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: as above
